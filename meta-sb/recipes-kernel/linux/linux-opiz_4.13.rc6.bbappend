FILESEXTRAPATHS_prepend := "${THISDIR}/linux-opi:"


SRC_URI += " \
    file://usb2_3.patch \
"
